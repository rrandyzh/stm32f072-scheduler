# Keil uVision project 6dofController.uvprojx, settings and files
target 6dofController (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: 6dofController +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB,INTERNAL_PULLUP,USE_USB_DEVICE_FS
  c include: ..\Main\Init\inc;..\Middlewares\ST\STM32_USB_Device_Library\Class\CustomHID\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\Drivers\STM32F0xx_HAL_Driver\Inc;..\Main\Usb\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/User
    ../Main/Init/src/: app_mcu_utils.c main.c stm32f0xx_it.c sys_scheduler.c system_init.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072xb.s
  group Drivers/STM32F0xx_StdPeriph_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_can.c stm32f0xx_hal_cec.c stm32f0xx_hal_comp.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_irda.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_msp_template.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_smartcard.c stm32f0xx_hal_smartcard_ex.c stm32f0xx_hal_smbus.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_tsc.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_wwdg.c
  group Middlewares/STM32_USBD_Library/Core
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/STM32_USBD_Library/Class/HID
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
    ../Main/Usb/src/: usb_dfu.c
  group Middlewares/STM32_USBD_Device/Driver
    ../Main/Usb/src/: usb_device.c usbd_conf.c usbd_custom_hid_if.c usbd_desc.c
